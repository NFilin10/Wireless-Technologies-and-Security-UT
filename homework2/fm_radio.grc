options:
  parameters:
    author: Nikita Filin
    generate_options: qt_gui
    id: fm_radio
    output_language: python
    title: FM Radio
  states: {}

blocks:
- name: browse
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: (4, 0)
    label: Browse
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: freq_change
  id: variable_qtgui_range
  parameters:
    gui_hint: (3, 0)
    label: Choose frequency
    outputmsgname: value
    showports: 'False'
    start: 88e6
    step: 1e5
    stop: 108e6
    value: 88.5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: station_chooser
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (2, 0)
    label: Select saved station
    label0: '90.3'
    label1: '94.4'
    label2: '99.4'
    label3: '100.2'
    label4: '104.2'
    num_opts: '5'
    option0: 90.3e6
    option1: 94.4e6
    option2: 99.4e6
    option3: 100.2e6
    option4: 104.2e6
    type: real
    value: 90.3e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_module.set_center_frequency(freq_change) - freq_change if browse == 1 else freq_module.set_center_frequency(station_chooser) - station_chooser
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: cc
  states: {}
- name: freq_module
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\n\ndef set_center_frequency(arg):\n\n\tif 88e6 <= arg <= 92.9e6:\n\t\treturn 90.5e6\n\t\t\n\telif 93e6 <= arg <= 97.9e6:\n\t\treturn 95.5e6\n\t\t\n\telif 98e6 <= arg <= 103e6:\n\t\treturn 100.5e6\n\t\t\n\telif 103e6 <= arg <= 108e6:\n\t\treturn 105.5e6\n\t\t\n"
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: int(0.75*(channel_width/2))
    decim: '25'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: int(0.25*(channel_width/2))
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 'freq_module.set_center_frequency(freq_change) if browse == 1 else freq_module.set_center_frequency(station_chooser) '
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq_change if browse == 1 else station_chooser
    fftsize: '1024'
    gui_hint: (1, 0)
    name: '"Adjusted Signals"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 'freq_module.set_center_frequency(freq_change) if browse == 1 else freq_module.set_center_frequency(station_chooser) '
    fftsize: '1024'
    gui_hint: (0, 0)
    name: '"Original Input"'
    type: complex
    update_time: '0.1'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    type: ccc
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [dc_blocker_xx_0, '0', blocks_multiply_xx_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', dc_blocker_xx_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
