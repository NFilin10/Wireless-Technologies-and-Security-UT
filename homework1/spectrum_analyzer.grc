options:
  parameters:
    author: Nikita Filin
    generate_options: qt_gui
    id: spectrum_analyzer
    output_language: python
    title: Analyzer
  states: {}

blocks:
- name: browse_by_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0, 0
    label: '" "'
    type: string
    value: 'Browse by:'
  states: {}
- name: freq_change
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 0
    label: Frequency slider
    outputmsgname: value
    showports: 'False'
    start: 1e6
    step: 0.1e6
    stop: 6e9
    value: 24e8
  states: {}
- name: mode_chooser
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1, 0
    label0: Slider
    label1: Quick select
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: options_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 3, 0
    label: '" "'
    type: string
    value: 'Range Selector:'
  states: {}
- name: predefined_options
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 4, 0
    label0: FM Radio
    label1: WiFi
    label2: ISM
    label3: GPS
    num_opts: '4'
    option0: 9.8e7
    option1: 2.4e9
    option2: 8.68e8
    option3: 1.227e9
    orient: Qt.QHBoxLayout
    type: real
    value: 9.8e7
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq_change if mode_chooser == 0 else predefined_options
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq_change if mode_chooser == 0 else predefined_options
    fftsize: '1024'
    gui_hint: 6, 0
    type: complex
    update_time: '2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq_change if mode_chooser == 0 else predefined_options
    fftsize: '1024'
    gui_hint: 5, 0
    type: complex
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
